## Kconfig
```kconfig
config RTL8723BU
	tristate "Realtek 8723B USB WiFi lixw"
	depends on USB
	---help---
	  Help message of RTL8723BU
```
